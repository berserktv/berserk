CFLAGS_append = " -latomic"
