FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

INITSCRIPT_PARAMS = "start 17 2 3 4 5 . stop 10 0 6 1 ."


