# change binconfig-disabled on enabled
inherit autotools texinfo binconfig pkgconfig


